//------------------------------------------------------------------------------
// Файл   : median_avg_filter.sv
// Модуль : median_avg_filter - медианно-усредняющая фильтрация
//
// Алгоритм ("усечённое среднее")
//   Из WINDOW_SIZE замеров (по умолчанию 10) отбрасываем самый маленький и
//   самый большой, остальные WINDOW_SIZE-2 (8) усредняем:
//
//        результат = (сумма - минимум - максимум) / 8
//
//   Деление на 8 - это сдвиг вправо на AVG_SHIFT = 3 бита.
//   Хранить и сортировать 10 чисел не нужно: по мере прихода замеров
//   достаточно держать три регистра - сумму, минимум и максимум.
//
// Ошибки
//   Замер с s_err = 1 в фильтр не попадает (ни в сумму, ни в min/max),
//   но занимает своё место в окне из 10 замеров.
//   Если в окне была хотя бы одна ошибка, на выход выдаётся err = 1 и
//   dist_mm = 0 (расстояние в этом случае не определено).
//
// Выход
//   После 10-го замера выдаются dist_mm и err и строб strobe длительностью
//   ОДИН такт. Данные меняются только вместе со стробом и держатся до
//   следующего - потребителю достаточно "защёлкивать" их по strobe = 1.
//
// Граф переходов
//
//   S_ACC --10-й замер, ошибок нет--> S_SUB_MIN --> S_SUB_MAX --> S_OUT
//     ^  \--10-й замер, были ошибки---------------------------> S_OUT
//     +----------------------------------------------------------------+
//
//   S_ACC      накопление: на каждый s_valid обновляем сумму, min, max;
//   S_SUB_MIN  tmp = сумма - минимум;
//   S_SUB_MAX  результат = (tmp - максимум) >> AVG_SHIFT;
//   S_OUT      строб strobe, очистка окна.
//   Вычитания разнесены по тактам, чтобы две цепочки переноса не шли подряд.
//
//   При en = 0 окно очищается, автомат возвращается в S_ACC;
//   выходные данные при этом сохраняют прежнее значение.
//
// Структура модуля - классический автомат из трёх блоков
//
//              +----------------------------------------+
//              |                 *_reg                  |
//              v                                        |
//        +-----------+  *_next  +-----------+           |
//  вх. ->| БЛОК 1    |--------->| БЛОК 2    |-----------+--------+
//        | следующее |          | регистры  |                    |
//        | состояние |          | (clk,rst) |                    v
//        | (комб.)   |          +-----------+              +-----------+
//        +-----------+                                     | БЛОК 3    |--> dist_mm
//                                                          | выходы    |--> err
//                                                          | (комб.)   |--> strobe
//                                                          +-----------+
//
//   "Состояние" автомата здесь расширенное: управляющее состояние (state)
//   плюс регистры данных (cnt, sum, min, max, tmp, werr, odist, oerr).
//   Поэтому блок 1 считает следующие значения ВСЕХ этих регистров.
//
//   Замечание про тип автомата: в исходном VHDL выходы зависят только от
//   регистров (strobe = "состояние S_OUT", dist_mm/err - выходные регистры)
//   и не зависят от входов, то есть это вырожденный случай Мили (по сути -
//   Мур). Трёхблочная структура сохранена, поведение совпадает с VHDL
//   такт в такт. Привязать выходы к входам (настоящий Мили) нельзя без
//   изменения поведения: строб перестал бы быть ровно одним тактом,
//   привязанным к состоянию S_OUT.
//
// Допущения
//   * s_valid приходит редко (раз в 100 мс), заведомо реже, чем автомат
//     успевает обработать окно (4 такта) - приход s_valid вне S_ACC
//     игнорируется;
//   * rst - синхронный сброс, активный уровень 1.
//   * Должно выполняться WINDOW_SIZE - 2 = 2**AVG_SHIFT, иначе сдвиг
//     не будет делением на число усредняемых замеров.
//   * В VHDL-версии DIST_WIDTH брался из пакета rangefinder_pkg. Здесь это
//     параметр модуля; значение 12 выбрано по комментарию в оригинале
//     (максимум 4095). Подставьте своё значение.
//------------------------------------------------------------------------------

module median_avg_filter #(
    parameter int WINDOW_SIZE = 10,  // сколько замеров в окне
    parameter int AVG_SHIFT   = 3,   // на сколько бит сдвинуть сумму (деление на 2**AVG_SHIFT)
    parameter int DIST_WIDTH  = 12   // разрядность расстояния, бит
) (
    input  logic                  clk,      // тактовая частота
    input  logic                  rst,      // синхронный сброс, активный уровень 1
    input  logic                  en,       // 1 - работа разрешена (switch включён)

    // Вход: результаты одиночных измерений от драйвера
    input  logic                  s_valid,  // строб: на s_dist / s_err лежит новый замер (1 такт)
    input  logic [DIST_WIDTH-1:0] s_dist,   // расстояние, мм
    input  logic                  s_err,    // 1 - замер неудачный

    // Выход: итог по окну
    output logic [DIST_WIDTH-1:0] dist_mm,  // отфильтрованное расстояние, мм
    output logic                  err,      // 1 - в окне был неудачный замер
    output logic                  strobe    // строб готовности, ровно 1 такт
);

    //--------------------------------------------------------------------------
    // Типы и константы
    //--------------------------------------------------------------------------
    typedef enum logic [1:0] {
        S_ACC     = 2'd0,
        S_SUB_MIN = 2'd1,
        S_SUB_MAX = 2'd2,
        S_OUT     = 2'd3
    } state_t;

    // Разрядность суммы: хватает для WINDOW_SIZE максимально возможных значений
    // (10 * 4095 = 40950 < 2**16).
    localparam int SUM_WIDTH = DIST_WIDTH + $clog2(WINDOW_SIZE);

    // Разрядность счётчика замеров (0 .. WINDOW_SIZE-1); минимум 1 бит.
    localparam int CNT_WIDTH = (WINDOW_SIZE > 1) ? $clog2(WINDOW_SIZE) : 1;

    // Номер последнего замера в окне.
    localparam [CNT_WIDTH-1:0] CNT_LAST = WINDOW_SIZE - 1;

    // Начальные значения регистров окна.
    localparam [SUM_WIDTH-1:0]  SUM_INIT  = '0;  // для сброса суммы
    localparam [DIST_WIDTH-1:0] MIN_INIT  = '1;  // "больше любого"
    localparam [DIST_WIDTH-1:0] MAX_INIT  = '0;  // "меньше любого"
    localparam [DIST_WIDTH-1:0] DIST_ZERO = '0;  // для сброса выхода

    //--------------------------------------------------------------------------
    // Текущее состояние: выходы регистров (суффикс _reg).
    // Начальные значения - состояние после загрузки FPGA.
    //--------------------------------------------------------------------------
    state_t                  state_reg = S_ACC;
    logic [CNT_WIDTH-1:0]    cnt_reg   = '0;        // принято замеров
    logic [SUM_WIDTH-1:0]    sum_reg   = SUM_INIT;  // сумма исправных замеров
    logic [DIST_WIDTH-1:0]   min_reg   = MIN_INIT;  // минимум
    logic [DIST_WIDTH-1:0]   max_reg   = MAX_INIT;  // максимум
    logic [SUM_WIDTH-1:0]    tmp_reg   = SUM_INIT;  // сумма без минимума
    logic                    werr_reg  = 1'b0;      // в окне была ошибка (хранится до конца окна)
    logic [DIST_WIDTH-1:0]   odist_reg = DIST_ZERO; // выход: расстояние
    logic                    oerr_reg  = 1'b0;      // выход: ошибка

    //--------------------------------------------------------------------------
    // Следующее состояние: входы регистров (суффикс _next).
    // Вычисляются в блоке 1, записываются в регистры в блоке 2.
    //--------------------------------------------------------------------------
    state_t                  state_next;
    logic [CNT_WIDTH-1:0]    cnt_next;
    logic [SUM_WIDTH-1:0]    sum_next;
    logic [DIST_WIDTH-1:0]   min_next;
    logic [DIST_WIDTH-1:0]   max_next;
    logic [SUM_WIDTH-1:0]    tmp_next;
    logic                    werr_next;
    logic [DIST_WIDTH-1:0]   odist_next;
    logic                    oerr_next;

    //--------------------------------------------------------------------------
    // Промежуточные величины блока 1 (именованные выражения, не регистры).
    //--------------------------------------------------------------------------
    logic                    last_sample;    // принимаемый замер - последний в окне
    logic                    window_err;     // ошибка в окне с учётом текущего замера
    logic                    clear_window;   // пора очистить регистры окна
    logic [SUM_WIDTH-1:0]    sample_wide;    // замер, расширенный нулями до ширины суммы
    logic [SUM_WIDTH-1:0]    min_wide;       // минимум, расширенный до ширины суммы
    logic [SUM_WIDTH-1:0]    max_wide;       // максимум, расширенный до ширины суммы
    logic [SUM_WIDTH-1:0]    sum_minus_min;  // (сумма - минимум)
    logic [SUM_WIDTH-1:0]    avg_wide;       // (сумма - мин - макс) / 2**AVG_SHIFT, ширина суммы


    //==========================================================================
    // БЛОК 1. Комбинационная логика СЛЕДУЮЩЕГО СОСТОЯНИЯ.
    //         Вход: текущее состояние (*_reg) и входы модуля.
    //         Выход: следующее состояние (*_next) - и управляющее, и данные.
    //==========================================================================
    always_comb begin : comb_next_state

        // ---- 0. Именованные выражения ----------------------------------------
        last_sample   = (cnt_reg == CNT_LAST);
        window_err    = werr_reg | s_err;

        // Окно очищается при выключенном switch и после выдачи результата.
        clear_window  = ~en | (state_reg == S_OUT);

        // Вычитания: операнды приводим к ширине суммы (присваивание в более
        // широкую переменную дополняет нулями). Сдвиг вправо = деление на
        // 2**AVG_SHIFT. Итог не превышает 4000, поэтому при сужении до
        // DIST_WIDTH старшие биты пусты.
        sample_wide   = s_dist;
        min_wide      = min_reg;
        max_wide      = max_reg;
        sum_minus_min = sum_reg - min_wide;
        avg_wide      = (tmp_reg - max_wide) >> AVG_SHIFT;

        // ---- 1. Значения по умолчанию: всё сохраняется -----------------------
        state_next = state_reg;
        cnt_next   = cnt_reg;
        sum_next   = sum_reg;
        min_next   = min_reg;
        max_next   = max_reg;
        tmp_next   = tmp_reg;
        werr_next  = werr_reg;
        odist_next = odist_reg;
        oerr_next  = oerr_reg;

        // ---- 2. Следующее УПРАВЛЯЮЩЕЕ состояние ------------------------------
        if (!en) begin
            state_next = S_ACC;                 // switch выключен: начинаем окно заново
        end else begin
            case (state_reg)

                S_ACC: begin                    // копим замеры
                    if (s_valid && last_sample) begin
                        if (window_err)
                            state_next = S_OUT;      // были ошибки: считать нечего, сразу выдаём ошибку
                        else
                            state_next = S_SUB_MIN;
                    end
                end

                S_SUB_MIN: state_next = S_SUB_MAX;

                S_SUB_MAX: state_next = S_OUT;

                S_OUT:     state_next = S_ACC;

                default:   state_next = S_ACC;  // защита от "битого" состояния

            endcase
        end

        // ---- 3. Следующие значения РЕГИСТРОВ ДАННЫХ --------------------------
        if (clear_window) begin
            // Очистка окна. Выходные данные (odist, oerr) и tmp не трогаем.
            cnt_next  = '0;
            sum_next  = SUM_INIT;
            min_next  = MIN_INIT;
            max_next  = MAX_INIT;
            werr_next = 1'b0;
        end else begin
            case (state_reg)

                S_ACC: begin
                    if (s_valid) begin
                        // Счёт замеров в окне
                        if (last_sample)
                            cnt_next = '0;
                        else
                            cnt_next = cnt_reg + 1'b1;

                        // Ошибка запоминается до конца окна
                        if (s_err) begin
                            werr_next = 1'b1;
                        end else begin
                            // Исправный замер: в сумму, при необходимости - в min и max
                            sum_next = sum_reg + sample_wide;
                            if (s_dist < min_reg)
                                min_next = s_dist;
                            if (s_dist > max_reg)
                                max_next = s_dist;
                        end

                        // Последний замер окна, а в окне были ошибки: сразу готовим выход
                        if (last_sample && window_err) begin
                            odist_next = DIST_ZERO;
                            oerr_next  = 1'b1;
                        end
                    end
                end

                S_SUB_MIN: begin
                    tmp_next = sum_minus_min;           // сумма без минимума
                end

                S_SUB_MAX: begin
                    odist_next = avg_wide[DIST_WIDTH-1:0];  // (сумма - мин - макс) / 8
                    oerr_next  = 1'b0;
                end

                default: ;                              // S_OUT сюда не попадает (clear_window = 1)

            endcase
        end
    end


    //==========================================================================
    // БЛОК 2. РЕГИСТРЫ состояния (единственный тактируемый блок).
    //         Сброс синхронный, активный уровень 1.
    //==========================================================================
    always_ff @(posedge clk) begin : seq_state_regs
        if (rst) begin
            state_reg <= S_ACC;
            cnt_reg   <= '0;
            sum_reg   <= SUM_INIT;
            min_reg   <= MIN_INIT;
            max_reg   <= MAX_INIT;
            tmp_reg   <= SUM_INIT;
            werr_reg  <= 1'b0;
            odist_reg <= DIST_ZERO;
            oerr_reg  <= 1'b0;
        end else begin
            state_reg <= state_next;
            cnt_reg   <= cnt_next;
            sum_reg   <= sum_next;
            min_reg   <= min_next;
            max_reg   <= max_next;
            tmp_reg   <= tmp_next;
            werr_reg  <= werr_next;
            odist_reg <= odist_next;
            oerr_reg  <= oerr_next;
        end
    end


    //==========================================================================
    // БЛОК 3. Комбинационная логика ВЫХОДОВ.
    //         Вход: текущее состояние (*_reg). Выход: порты модуля.
    //==========================================================================
    always_comb begin : comb_outputs
        // Данные: выходные регистры. Меняются только на переходе в S_OUT
        // (одновременно с появлением строба) и держатся до следующего результата.
        dist_mm = odist_reg;
        err     = oerr_reg;

        // Строб готовности: ровно один такт - пока автомат в S_OUT.
        // Выходные данные были записаны при входе в S_OUT и в этом такте стабильны.
        strobe  = (state_reg == S_OUT);
    end

endmodule : median_avg_filter